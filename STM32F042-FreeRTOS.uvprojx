# Keil uVision project STM32F042-FreeRTOS.uvprojx, settings and files
target BUTTERFLY_RemoteControl (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F042-SWITCHV10 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c misc: --c99 --diag-suppress 111
  c include: .\src\User_Files;.\src\Official_Files\CMSIS;.\src\Official_Files\STM32F0xx_StdPeriph_Driver;.\src\Official_Files\FreeRTOS_V8_1_2\Source;.\src\Official_Files\FreeRTOS_V8_1_2\Source\include;.\src\Official_Files\FreeRTOS_V8_1_2\Source\portable\MemMang;.\src\Official_Files\FreeRTOS_V8_1_2\Source\portable\RVDS\ARM_CM0;.\src\Official_Files\STM32F0xx_StdPeriph_Driver\inc;.\src\Official_Files\STM32F0xx_StdPeriph_Driver\src;.\src\Official_Files\STM32F0xx_StdPeriph_Driver\startup\ARM;.\Driver;.\mylib;.\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./src/User_Files/: stm32f0xx_it.c
    ./Driver/: delay.c drv_adc.c Led.c NRF24L01.C SPI.c main.c
  group FreeRTOS
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/portable/MemMang/: heap_2.c
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/: timers.c tasks.c queue.c list.c croutine.c
  group STM32F0xx_StdPeriph_Driver
    ./src/Official_Files/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_spi.c stm32f0xx_rtc.c stm32f0xx_rcc.c stm32f0xx_pwr.c stm32f0xx_iwdg.c stm32f0xx_i2c.c stm32f0xx_gpio.c stm32f0xx_flash.c stm32f0xx_exti.c stm32f0xx_can.c stm32f0xx_adc.c stm32f0xx_misc.c
    ./src/Official_Files/STM32F0xx_StdPeriph_Driver/: system_stm32f0xx.c
  group CM0
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/: FreeRTOSConfig.h
    ./src/Official_Files/STM32F0xx_StdPeriph_Driver/: stm32f0xx_conf.h
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/portable/RVDS/ARM_CM0/: port.c
    ./CORE/: startup_stm32f030.s
